FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

dirs755 += "/mnt/boot"
